inherit externalsrc
EXTERNALSRC = "/home/invite/w/src/esme-3S1/esme-3S1-gpio-toggle"
EXTERNALSRC_BUILD = "/home/invite/w/src/esme-3S1/esme-3S1-gpio-toggle"
